# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LED;..\USER\LCD;..\SYSTEM\delay;..\SYSTEM\sys;..\USER\KEY;..\USER\KeyBoard;..\USER\HanZi;..\USER\W25QXX;..\USER\TF_SDIO;..\USER\MALLOC;..\USER\FATFS;..\USER\SPI;..\USER\FATFS\src\option;..\USER\FATFS\src;..\USER\KEY_IT;..\USER\EXTI;..\USER\SIN;..\USER\DAC;..\USER\TIM;..\USER\FUNCTION;..\USER\SI5351;..\USER\I2C;..\USER\TM1637;..\USER\ADF4351
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c README.txt
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/LED/: led.c
    ../USER/LCD/: lcd.c
    ../USER/KeyBoard/: KeyBoard.c
    ../USER/HanZi/: HanZiUse.lib
    ../USER/W25QXX/: w25qxx.c
    ../USER/MALLOC/: malloc.c
    ../USER/SPI/: spi.c
    ../USER/KEY_IT/: key_it.c
    ../USER/EXTI/: exti.c
    ../USER/TF_SDIO/: tfcard_sdio.c
    ../USER/FATFS/src/: diskio.c ff.c
    ../USER/FATFS/: cc936.c
    ../USER/TIM/: timer.c
    ../USER/DAC/: dac.c
    ../USER/SIN/: sinx.c
    ../USER/FUNCTION/: function.c
    ../USER/TM1637/: tm1637.c
    ../USER/SI5351/: si5351.c
    ../USER/ADF4351/: ADF4351.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_dac.c stm32f4xx_i2c.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
software components: CMSIS:CORE 4.3.0
